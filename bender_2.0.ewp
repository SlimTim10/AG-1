# IAR project bender_2.0.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5310 MSP430F5310
  General.GStackSize2: 300
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: C:\Users\Icewire\Dropbox\Prototype\bender\code\bender\lnk430f5310_bender.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: accelbuffer.c accelbuffer.h buttonbuffer.c buttonbuffer.h circuit.c circuit.h const.h L3G4200D.c L3G4200D.h LIS3LV02DL.c LIS3LV02DL.h lnk430f5310_bender.xcl macro.h main.c main.h msp430f5310_extra.c msp430f5310_extra.h sdfat.c sdfat.h spi.c spi.h util.c util.h
